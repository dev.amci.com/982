PROGRAM MAIN
VAR
END_VAR

AMCI_Motion_Sample ();
AMCI_Assembled_Move_Sample ();

END_PROGRAM
